# Keil uVision project software.uvprojx, settings and files
target software (6190000::V6.19::ARMCLANG)
  device: GD32F425RG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: software
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F425
  c include: ..\core\inc;..\app\inc;..\periph\GD32F4xx_standard_peripheral\inc;..\periph\CMSIS\GD\GD32F4xx\Include;..\periph\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/src/: main.c
  group core
    ../core/src/: systick.c sys_param.c gd32f4xx_it.c
  group periph
    ../periph/GD32F4xx_standard_peripheral/src/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group startup
    ../periph/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../periph/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f405_425.s
  group driver
    ../driver/src/: drv_gpio.c drv_led.c
  group bsp
    ../bsp/src/: bsp_gpio.c bsp_led.c
